/* *******************************************************************************

	DELAYS PARA USO GERAL
	FELIPE LOPASSO RODRIGUES - 12/12/2009

	DEFINIÇÕES EXTERNAS NECESSÁRIAS PARA USO DAS SUBROTINAS:

// *** CONSTANTES ***
	FREQ -> VALOR DA FREQUÊNCIA DO MICROCONTROLADOR, DE 1 A 20, APENAS INTEIROS

// *** REGISTRADORES ***
	TMP -> PARÂMETRO PARA O VALOR DO DELAY EM mS					>R16
	TMP2, TMP3	->	REGISTRADORES USADOS DENTRO DA ROTINA	>R16

******************************************************************************* */

// *******************************************************************************
//		DELAY DE 1 A 255 s

DELAY_S:
	PUSH	TMP
	PUSH	TMP2		// SALVA CONTEUDO DE TMP2
	MOV		TMP2,TMP

	CPI		TMP,0
	BREQ	NODEL1S

DEL_1S:
	LDI		TMP,250		// FAZ DELAY DE 1 s
	RCALL	DELAY_MS
	LDI		TMP,250
	RCALL	DELAY_MS
	LDI		TMP,250
	RCALL	DELAY_MS
	LDI		TMP,250
	RCALL	DELAY_MS

	DEC		TMP2		// DECREMENTA CONTADOR DE SEGUNDOS
	BRNE	DEL_1S		// SE NAO CHEGOU A 0, CONTINUA DELAY
NODEL1S:
	POP		TMP2		// RECUPERA CONTEUDO DE TMP2
	POP		TMP
	RET

// *******************************************************************************
//		DELAY DE 10 ms A 2550 ms

DELAY_DS:
	PUSH	TMP2		// SALVA CONTEUDO DE TMP2
	PUSH	TMP

	CPI		TMP,0
	BREQ	NODELDS
	MOV		TMP2,TMP
DEL_10MS:
	LDI		TMP,10		// FAZ DELAY DE 10 ms
	RCALL	DELAY_MS

	DEC		TMP2		// DECREMENTA CONTADOR DE SEGUNDOS
	BRNE	DEL_10MS	// SE NAO CHEGOU A 0, CONTINUA DELAY
NODELDS:
	POP		TMP
	POP		TMP2		// RECUPERA CONTEUDO DE TMP2
	RET
// *******************************************************************************
//		DELAY DE 1 A 250 mS; ERRO MÁXIMO = 1.7 % (1 mS @ 1 MHz)
//		NUM_INST = 	(1000*FREQ + 3)*[TMP] + 16 (CONSIDERANDO RCALL DELAY_MS E RET)
//		NAO ALTERA O VALOR DE REGISTRADORES

DELAY_MS:
	PUSH	TMP
	PUSH	TMP2			// SALVA REGISTRADORES
	PUSH	TMP3

	CPI		TMP,0
	BREQ	NODELMS
DEL_1_MS:					// 1 mS = 1000*FREQ = (996 + 4)*FREQ (BRNE(FALSE) COMPENSA O LDI)
	LDI		TMP2,FREQ		

MAIS_996_INST:				// 996 = 249*4 (BRNE(FALSE) COMPENSA O LDI)
	LDI		TMP3,249

QUATRO_INST:				// NOP + DEC + BRNE(TRUE) = 4
	NOP
	DEC		TMP3
	BRNE	QUATRO_INST		// VERIFICA SE JÁ FEZ 249 ITERAÇÕES DE 4 INSTRUCOES

	NOP
	DEC		TMP2
	BRNE	MAIS_996_INST	// VERIFICA SE JÁ FEZ "FREQ" ITERAÇÕES DE 1000 INSTRUCOES

	DEC		TMP
	BRNE	DEL_1_MS		// VERIFICA SE JÁ FEZ "TMP" ITERAÇÕES DE 1 mS
NODELMS:
	POP		TMP3			// RESTAURA REGISTRADORES
	POP		TMP2
	POP		TMP
	RET						// RETORNA

// *******************************************************************************
//		DELAY DE 100 A 2500 us; ERRO MÁXIMO = ?
//		NUM_INST = 	(1000*FREQ + 3)*[TMP] + 14 (CONSIDERANDO RCALL DEL100_US E RET)
//		NAO ALTERA O VALOR DE REGISTRADORES

DEL100_US:
	PUSH	TMP
	PUSH	TMP2			// SALVA REGISTRADORES
	PUSH	TMP3

DEL_100_US:					// 100 uS = 100*FREQ INSTRUCOES = (96 + 4)*FREQ (BRNE(FALSE) COMPENSA O LDI) (1/FREQ)
	LDI		TMP2,FREQ		

MAIS_96_INST:				// 96 = 24*4 (BRNE(FALSE) COMPENSA O LDI)
	LDI		TMP3,24

Q_INST:						// NOP + DEC + BRNE(TRUE) = 4
	NOP
	DEC		TMP3
	BRNE	Q_INST			// VERIFICA SE JÁ FEZ 24 ITERAÇÕES DE 4 INSTRUCOES

	NOP
	DEC		TMP2
	BRNE	MAIS_96_INST	// VERIFICA SE JÁ FEZ "FREQ" ITERAÇÕES DE 100 INSTRUCOES

	DEC		TMP
	BRNE	DEL_100_US		// VERIFICA SE JÁ FEZ "R16" ITERAÇÕES DE 100 uS

	POP		TMP3			// RESTAURA REGISTRADORES
	POP		TMP2
	POP		TMP
	RET						// RETORNA

// -------------------------------------------------------------------------------
//		DELAY DE 5 uS @ 12/4 MHz


//	P/ 12 MHZ
							// NUMERO DE INSTRUCOES
DEL_5_US:					//	3
//RET
	PUSH	TMP				//	2
	LDI		TMP,6			//	1
DEL_5_DEC:
	DEC		TMP				//	1
	BRNE	DEL_5_DEC		//	2

	POP		TMP				//	2
	RET						//	4


/*	P/ 4 MHZ
							// NUMERO DE INSTRUCOES
DEL_5_US:					//	3
	PUSH	TMP2			//	2
	LDI		TMP2,2			//	1
DEL_5_DEC:
	DEC		TMP2			//	1
	BRNE	DEL_5_DEC		//	2

	POP		TMP2			//	2
	RET						//	4
*/	


